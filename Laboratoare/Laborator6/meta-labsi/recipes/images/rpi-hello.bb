require recipes-core/images/rpi-basic-image.bb

IMAGE_INSTALL += "hello"
