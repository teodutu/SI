require recipes-core/images/rpi-basic-image.bb

IMAGE_INSTALL += "xmas-tree"
